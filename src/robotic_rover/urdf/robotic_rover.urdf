Commit message: Add ROS control, lidar, and IMU

File: src/robotic_rover/urdf/robotic_rover.urdf (robot description, URDF)
Before this commit: robot robotic_rover, 9 links, 8 joints
Links:
- link base_link: mass 3.71042030200522 -> 10.0
